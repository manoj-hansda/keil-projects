# Keil uVision project pass_fail.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: pass_fail +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: pass_fail.c
